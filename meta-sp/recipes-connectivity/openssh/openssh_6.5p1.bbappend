RDEPENDS_${PN}-sshd += "libgoogle-authenticator \
			    "
