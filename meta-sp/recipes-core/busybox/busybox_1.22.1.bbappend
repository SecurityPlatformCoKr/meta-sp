# to get brctl and log configuration settings
FILESEXTRAPATHS_prepend := "${THISDIR}/files/:"

SRC_URI += " file://syslogd.cfg \
	   "
