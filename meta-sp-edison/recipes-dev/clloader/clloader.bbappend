FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://trivial_fix.patch"
