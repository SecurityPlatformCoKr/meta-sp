IMAGE_INSTALL += "packagegroup-i2ctpm"
IMAGE_INSTALL += "busybox-udhcpd \
		  sp-dev-config \
		  uhttpd \
		  luci luci-i18n-english \
		  ecryptfs-utils mount-secure \
		 "
#		  busybox-syslog 
