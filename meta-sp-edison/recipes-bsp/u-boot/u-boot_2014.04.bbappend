FILESEXTRAPATHS_prepend := "${THISDIR}/files"

SRC_URI += "file://fix_k2m.patch"
