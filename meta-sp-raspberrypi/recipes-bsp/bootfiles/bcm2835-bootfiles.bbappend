RDEPENDS_${PN} += "extlinux-conf"
