FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://tpm_i2c_atmel.patch \
	    file://tpm.cfg "
