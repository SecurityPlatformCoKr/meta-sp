IMAGE_INSTALL += "packagegroup-i2ctpm"
IMAGE_INSTALL += "busybox-syslog"
IMAGE_INSTALL += "sp-dev-config "
