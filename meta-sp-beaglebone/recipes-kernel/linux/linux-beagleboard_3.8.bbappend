COMPATIBLE_MACHINE="beaglebone"
DEPENDS += "u-boot-mkimage-native"
